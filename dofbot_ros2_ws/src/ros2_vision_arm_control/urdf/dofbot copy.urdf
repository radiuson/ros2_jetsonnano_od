Commit message: fxfy=607.5303

File: dofbot_ros2_ws/src/ros2_vision_arm_control/urdf/dofbot copy.urdf (robot description, URDF)
Before this commit: robot dofbot, 7 links, 6 joints
Links:
- removed link link5
- removed link link6
Joints:
- removed joint joint5
- removed joint joint6
